#RDEPENDS:${PN}:remove = "python3 python3-shell pyxdg"