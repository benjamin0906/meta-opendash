INITSCRIPT_PARAMS = "start 10 S ."